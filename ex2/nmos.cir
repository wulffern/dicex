* Gate Voltage sweep

*----------------------------------------------------------------
* Include
*----------------------------------------------------------------
.include ../models/ptm_130.spi

*----------------------------------------------------------------
* Options
*----------------------------------------------------------------
.option TNOM=27 GMIN=1e-20

*----------------------------------------------------------------
* Sources
*----------------------------------------------------------------
V1 VD VSS dc 1.5
V2 VG VSS dc 0
V3 VSS 0 dc 0

*----------------------------------------------------------------
* DUT
*----------------------------------------------------------------
M1 VD VG VSS VSS nmos W=2u L=0.2u

*----------------------------------------------------------------
* Analysis
*----------------------------------------------------------------
.dc V2 0 1.5 0.01
.defwave a = gm(m1)*rds(m1)
.plot v(vg) gm(m1) rds(m1) id(m1) v(a)
