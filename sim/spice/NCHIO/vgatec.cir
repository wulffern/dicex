* Testbench to show Gate capacitance

*--------------------------------------------------------------
* INCLUDE
*--------------------------------------------------------------
.include ../../../models/ptm_130.spi

*--------------------------------------------------------------
* SOURCES
*--------------------------------------------------------------
vdrain D 0 dc 0
vgatec G 0 dc 0

* Voltage source to make it easy to mesure current through transistor
vcur S 0 dc 0
vbulk B 0 dc 0
*--------------------------------------------------------------
* DUT
*--------------------------------------------------------------

M1 D G S B nmos  w=1.08u  l=0.13u
*--------------------------------------------------------------
* ANALYSIS
*--------------------------------------------------------------
.dc vgatec -1.8 1.8 0.01

.plot I(vcur) cgs(m1)
