* Testbench to show IV curves for an NMOS

*--------------------------------------------------------------
* INCLUDE
*--------------------------------------------------------------
.include ../../../lib/SUN_TRIO_GF130N.spi
.include ../../../models/ptm_130.spi

*--------------------------------------------------------------
* SOURCES
*--------------------------------------------------------------
vdrain D 0 dc 1
vgaini G 0 dc 0.5
vbulk B 0 dc 0

* Voltage source to make it easy to mesure current through transistor
vcur S 0 dc 0

*--------------------------------------------------------------
* DUT
*--------------------------------------------------------------
M1 D G S B nmos  w=1.08u  l=0.13u

*--------------------------------------------------------------
* ANALYSIS
*--------------------------------------------------------------
.dc vgaini 0 1.8 0.01

.defwave a= gm(m1)/gds(m1)

.plot I(vcur) v(a)
