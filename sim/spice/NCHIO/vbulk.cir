* Testbench to show IV curves for an NMOS

*--------------------------------------------------------------
* INCLUDE
*--------------------------------------------------------------
.include ../../../lib/SUN_TRIO_GF130N.spi
.include ../../../models/ptm_130.spi

*--------------------------------------------------------------
* SOURCES
*--------------------------------------------------------------
vdrain D 0 dc 1
vgate G 0 dc 0.5
vbulk B 0 dc 0

* Voltage source to make it easy to mesure current through transistor
vcur S 0 dc 0

*--------------------------------------------------------------
* DUT
*--------------------------------------------------------------
X1 D G S B NCHIO

*--------------------------------------------------------------
* ANALYSIS
*--------------------------------------------------------------
.dc vbulk -1 0.3 0.01

.plot I(vcur)
