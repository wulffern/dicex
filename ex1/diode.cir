* Problem 3 - Diode simulation

*Include diode model
.include ../models/ptm_diode_130.spi

.option TNOM=27 GMIN=1e-20

V1 VDD 0 dc 5
D1 0 VDD pn_sub

.op
