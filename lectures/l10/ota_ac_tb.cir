* Check OP

*----------------------------------------------------------------
* Include
*----------------------------------------------------------------
.include ../../models/ptm_130.spi

*----------------------------------------------------------------
* Options
*----------------------------------------------------------------
.option TNOM=27 GMIN=1e-20 reltol=1e-8 abstol=1e-10

*----------------------------------------------------------------
* Sources
*----------------------------------------------------------------

V2 VSS 0 dc 0
V1 VDD 0 dc 1.5

I1 VDD IBP dc 1u

VGAC VIP VIN dc 0 ac 1
VG VIP 0 dc 0.7

CL VO VSS 1p

*----------------------------------------------------------------
* DUT
*----------------------------------------------------------------
.include cm.cir
.include ota.cir

X1 VIP VIN VO VDD VSS IBP OTA

*----------------------------------------------------------------
* Analysis
*----------------------------------------------------------------

.ac dec 50 1 10G

.plot vdb(vo) vp(vo)
