* Check DC

*----------------------------------------------------------------
* Include
*----------------------------------------------------------------
.include ../../models/ptm_130.spi

*----------------------------------------------------------------
* Options
*----------------------------------------------------------------
.option TNOM=27 GMIN=1e-20 reltol=1e-10 abstol=1e-10

*----------------------------------------------------------------
* Sources
*----------------------------------------------------------------

V2 VSS 0 dc 0
V1 VDD 0 dc 1.5

I1 VDD VDN0 dc 1u ac 1
VM VDN0 VDN dc 0

E1 IDN1 0 VDN 0 1
E2 IDN2 0 VDN 0 1
E3 IDN3 0 VDN 0 1

*----------------------------------------------------------------
* DUT
*----------------------------------------------------------------
.include cm.cir
X1 VDN IDN1 IDN2 IDN3 VSS CMIRR

*----------------------------------------------------------------
* Analysis
*----------------------------------------------------------------
.ac dec 50 1 1G

.plot ac  im(e1) im(e2) im(e3)
