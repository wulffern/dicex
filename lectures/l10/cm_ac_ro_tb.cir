* Check DC

*----------------------------------------------------------------
* Include
*----------------------------------------------------------------
.include ../../models/ptm_130.spi

*----------------------------------------------------------------
* Options
*----------------------------------------------------------------
.option TNOM=27 GMIN=1e-20 reltol=1e-6 abstol=1e-8

*----------------------------------------------------------------
* Sources
*----------------------------------------------------------------

V2 VSS 0 dc 0
V1 VDD 0 dc 1.5

I1 VDD VDN0 dc 1u
VM VDN0 VDN dc 0

VO1 IDN1 0 dc 0.5 ac 1
VO2 IDN2 0 dc 0.5 ac 1
VO3 IDN3 0 dc 0.5 ac 1

*----------------------------------------------------------------
* DUT
*----------------------------------------------------------------
X1 VDN IDN1 IDN2 IDN3 CMIRR

*----------------------------------------------------------------
* Analysis
*----------------------------------------------------------------

.op
