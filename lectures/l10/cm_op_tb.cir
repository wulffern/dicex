* Check OP

*----------------------------------------------------------------
* Include
*----------------------------------------------------------------
.include ../../models/ptm_130.spi

*----------------------------------------------------------------
* Options
*----------------------------------------------------------------
.option TNOM=27 GMIN=1e-20 reltol=1e-6 abstol=1e-8

*----------------------------------------------------------------
* Sources
*----------------------------------------------------------------

V2 VSS 0 dc 0
V1 VDD 0 dc 1.5

I1 VDD VDN0 dc 1u
VM VDN0 VDN dc 0

E1 IDN1 0 VDN 0 1
E2 IDN2 0 VDN 0 1
E3 IDN3 0 VDN 0 1

*----------------------------------------------------------------
* DUT
*----------------------------------------------------------------
.include cm.cir
X1 VDN IDN1 IDN2 IDN3 VSS CMIRR

*----------------------------------------------------------------
* Analysis
*----------------------------------------------------------------

B1 BD1 0 V=i(e1)/(-i(VM))
B2 BD2 0 V=i(e2)/(-i(VM))
B3 BD3 0 V=i(e3)/(-i(VM))

BE1 ERR1 0 V=(i(e1) + 2*i(VM))/(-i(VM))
BE2 ERR2 0 V=(i(e2) + 4*i(VM))/(-i(VM))
BE3 ERR3 0 V=(i(e3) + 8*i(VM))/(-i(VM))

.op
