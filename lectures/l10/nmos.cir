* Check gm/ID

*----------------------------------------------------------------
* Include
*----------------------------------------------------------------
.include ../../models/ptm_130.spi

*----------------------------------------------------------------
* Options
*----------------------------------------------------------------
.option TNOM=27 GMIN=1e-20 reltol=1e-6 abstol=1e-8

*----------------------------------------------------------------
* Sources
*----------------------------------------------------------------
V1 VDD VSS dc 1.5
V3 VSS 0 dc 0

I1 VDD VD 1u
*----------------------------------------------------------------
* DUT
*----------------------------------------------------------------
M1 VD VS VSS VSS nmos W=0.750u L=0.15u

*----------------------------------------------------------------
* Analysis
*----------------------------------------------------------------
.dc i1 0.01u 100u 0.1u
.defwave gmid = gm(m1)/i(m1)
.plot v(vg) v(vd) gm(m1) rds(m1) id(m1) v(gmid)
