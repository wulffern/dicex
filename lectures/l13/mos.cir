* Gate Voltage sweep

*----------------------------------------------------------------
* Include
*----------------------------------------------------------------
.include ../../models/ptm_130.spi

*----------------------------------------------------------------
* Options
*----------------------------------------------------------------
.option TNOM=27 GMIN=1e-20

*----------------------------------------------------------------
* Sources
*----------------------------------------------------------------
VD VD VSS dc {VD}
VG VG VSS dc {VG}
VS VSS 0 dc 0

*----------------------------------------------------------------
* DUT
*----------------------------------------------------------------
M1 VD VG VSS VSS nmos W=0.5u L=0.15u

*----------------------------------------------------------------
* Analysis
*----------------------------------------------------------------
.op
