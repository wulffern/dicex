* Current mirrors

*----------------------------------------------------------------
* Include
*----------------------------------------------------------------
.include ../models/ptm_130.spi
.include ../lib/SUN_TRIO_GF130N.spi

*----------------------------------------------------------------
* Options
*----------------------------------------------------------------
.option TNOM=27 GMIN=1e-20

*----------------------------------------------------------------
* Sources
*----------------------------------------------------------------
V1 VDD 0 dc  3.0
V2 VG 0 dc 1.5 ac 1
V3 VSS 0 dc 0

*----------------------------------------------------------------
* DUTs
*----------------------------------------------------------------
I1 0 VD dc 20u
XN1 VD VD VSS VSS NCHIOCM
XN2 VX VD VSS VSS NCHIOCM
XN3 VDD VG VX VX NCHIOA_12C

CL VX VSS 100f

*----------------------------------------------------------------
* Analysis
*----------------------------------------------------------------
*.op

.ac dec 50 1k 1G
.plot ac vm(vx)
