* Current mirrors

*----------------------------------------------------------------
* Include
*----------------------------------------------------------------
.include ../models/ptm_130.spi
.include ../lib/SUN_TRIO_GF130N.spi

*----------------------------------------------------------------
* Options
*----------------------------------------------------------------
.option TNOM=27 GMIN=1e-15

*----------------------------------------------------------------
* Sources
*----------------------------------------------------------------
V1 VDD 0 dc  3.0
V2 VG 0 dc 0 ac 1
V3 VSS 0 dc 0

*----------------------------------------------------------------
* DUTs
*----------------------------------------------------------------
I1 VDD VD dc 20u

XN1 VD VD VSS VSS NCHIOA

XN3 VX1 VD VSS VSS NCHIOA
XP3 VX1 VO VDD VDD PCHIOA_12C

R2 VDD VR 100k
R3 VR VSS 100k

XN4 VS VD VSS VSS NCHIOA
XM1 VO VR VS VSS NCHIOA_6C
XM2 VM1 VX1 VS VSS NCHIOA_6C
C2 VX1 VDD 1p
R4 VO VDD 100k
R5 VM1 VDD 100k

R1 VO VG1 500k
C1 VG VG1 10p
XN2 VX VD VSS VSS NCHIOA
XP4 VX VG1 VDD VDD PCHIOA_12C

*----------------------------------------------------------------
* Analysis
*----------------------------------------------------------------
*.op

*#com
.ac dec 50 1k 1G
.plot ac vm(vx)
*#endcom
