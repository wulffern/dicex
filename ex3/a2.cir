* Current mirrors

*----------------------------------------------------------------
* Include
*----------------------------------------------------------------
.include ../models/ptm_130.spi
.include ../lib/SUN_TRIO_GF130N.spi

*----------------------------------------------------------------
* Options
*----------------------------------------------------------------
.option TNOM=27 GMIN=1e-20

*----------------------------------------------------------------
* Sources
*----------------------------------------------------------------
V1 VDD 0 dc  3.0
V2 VG 0 dc 2 ac 1
V3 VSS 0 dc 0

*----------------------------------------------------------------
* DUTs
*----------------------------------------------------------------
I1 0 VD dc 8u
XN1 VD VD VSS VSS NCHIOA
XN2 VX VD VSS VSS NCHIOA
XN3 VX VG VDD VDD PCHIOA_4C

*----------------------------------------------------------------
* Analysis
*----------------------------------------------------------------
.op
#com
.dc V2 2 3 0.0001
.plot dc v(vx)
#endcom
#com
.ac dec 50 1k 1G
.plot ac vm(vx)
#endcom
